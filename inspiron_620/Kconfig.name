## inspiron_620/Kconfig.name
```kconfig
## SPDX-License-Identifier: GPL-2.0-only

config BOARD_DELL_INSPIRON_620
	bool "Inspiron 620"
```
